Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2025-10-17T11:53:56
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusARRAY, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusARRAY:222199
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth,Textured; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts. Prestige tiles have a smooth, finely textured surface providing good sound absorption and attenuation; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Prestige - Nexus layouts; Name: ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusARRAY_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusARRAY; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/ff32cfe2-feb0-42b1-9df5-0215e3131b51/427ff75e-6c4b-4de9-93d8-c2b28e706aa4; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 19 mm-thick mineral tiles, Global White; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill units: 5 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: αw = 0.70(H); Class C; SoundAttenuation: Infill units: acoustic attenuation to EN ISO 354 and EN ISO 11654, Dnfw = 37 dB; WeightedSoundReductionIndexRw: Infill units: To EN ISO 10848-2 and EN ISO 717-1, 20 dB; NoiseReductionCoefficient: Infill units: 0.70; VOCEmissions: Infill units: The VOC emission performance in accordance with the French labelling requirements: A; FormaldehydeEmissions: Infill units: To EN 13964, formaldehyde emission level E1 = Best test result possible; ColourLightReflectanceValueLRV: Infill units: 87%; CleanroomClassification: To ISO 14644-1, ISO 4; RelativeHumidity: Infill units: 87%; Design: ARRAY
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusARRAY 19 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusBERG, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusBERG:222207
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth,Textured; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts. Prestige tiles have a smooth, finely textured surface providing good sound absorption and attenuation; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Prestige - Nexus layouts; Name: ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusBERG_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusBERG; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/ff32cfe2-feb0-42b1-9df5-0215e3131b51/427ff75e-6c4b-4de9-93d8-c2b28e706aa4; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 19 mm-thick mineral tiles, Global White; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill units: 5 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: αw = 0.70(H); Class C; SoundAttenuation: Infill units: acoustic attenuation to EN ISO 354 and EN ISO 11654, Dnfw = 37 dB; WeightedSoundReductionIndexRw: Infill units: To EN ISO 10848-2 and EN ISO 717-1, 20 dB; NoiseReductionCoefficient: Infill units: 0.70; VOCEmissions: Infill units: The VOC emission performance in accordance with the French labelling requirements: A; FormaldehydeEmissions: Infill units: To EN 13964, formaldehyde emission level E1 = Best test result possible; ColourLightReflectanceValueLRV: Infill units: 87%; CleanroomClassification: To ISO 14644-1, ISO 4; RelativeHumidity: Infill units: 87%; Design: BERG
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusBERG 19 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusEXCLAIM, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusEXCLAIM:222215
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth,Textured; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts. Prestige tiles have a smooth, finely textured surface providing good sound absorption and attenuation; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Prestige - Nexus layouts; Name: ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusEXCLAIM_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusEXCLAIM; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/ff32cfe2-feb0-42b1-9df5-0215e3131b51/427ff75e-6c4b-4de9-93d8-c2b28e706aa4; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 19 mm-thick mineral tiles, Global White; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill units: 5 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: αw = 0.70(H); Class C; SoundAttenuation: Infill units: acoustic attenuation to EN ISO 354 and EN ISO 11654, Dnfw = 37 dB; WeightedSoundReductionIndexRw: Infill units: To EN ISO 10848-2 and EN ISO 717-1, 20 dB; NoiseReductionCoefficient: Infill units: 0.70; VOCEmissions: Infill units: The VOC emission performance in accordance with the French labelling requirements: A; FormaldehydeEmissions: Infill units: To EN 13964, formaldehyde emission level E1 = Best test result possible; ColourLightReflectanceValueLRV: Infill units: 87%; CleanroomClassification: To ISO 14644-1, ISO 4; RelativeHumidity: Infill units: 87%; Design: EXCLAIM
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusEXCLAIM 19 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusPIXAL, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusPIXAL:222223
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth,Textured; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts. Prestige tiles have a smooth, finely textured surface providing good sound absorption and attenuation; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Prestige - Nexus layouts; Name: ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusPIXAL_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusPIXAL; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/ff32cfe2-feb0-42b1-9df5-0215e3131b51/427ff75e-6c4b-4de9-93d8-c2b28e706aa4; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 19 mm-thick mineral tiles, Global White; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill units: 5 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: αw = 0.70(H); Class C; SoundAttenuation: Infill units: acoustic attenuation to EN ISO 354 and EN ISO 11654, Dnfw = 37 dB; WeightedSoundReductionIndexRw: Infill units: To EN ISO 10848-2 and EN ISO 717-1, 20 dB; NoiseReductionCoefficient: Infill units: 0.70; VOCEmissions: Infill units: The VOC emission performance in accordance with the French labelling requirements: A; FormaldehydeEmissions: Infill units: To EN 13964, formaldehyde emission level E1 = Best test result possible; ColourLightReflectanceValueLRV: Infill units: 87%; CleanroomClassification: To ISO 14644-1, ISO 4; RelativeHumidity: Infill units: 87%; Design: PIXAL
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusPIXAL 19 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusSTEP, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusSTEP:222231
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth,Textured; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts. Prestige tiles have a smooth, finely textured surface providing good sound absorption and attenuation; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Prestige - Nexus layouts; Name: ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusSTEP_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusSTEP; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/ff32cfe2-feb0-42b1-9df5-0215e3131b51/427ff75e-6c4b-4de9-93d8-c2b28e706aa4; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 19 mm-thick mineral tiles, Global White; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill units: 5 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: αw = 0.70(H); Class C; SoundAttenuation: Infill units: acoustic attenuation to EN ISO 354 and EN ISO 11654, Dnfw = 37 dB; WeightedSoundReductionIndexRw: Infill units: To EN ISO 10848-2 and EN ISO 717-1, 20 dB; NoiseReductionCoefficient: Infill units: 0.70; VOCEmissions: Infill units: The VOC emission performance in accordance with the French labelling requirements: A; FormaldehydeEmissions: Infill units: To EN 13964, formaldehyde emission level E1 = Best test result possible; ColourLightReflectanceValueLRV: Infill units: 87%; CleanroomClassification: To ISO 14644-1, ISO 4; RelativeHumidity: Infill units: 87%; Design: STEP
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_Prestige-NexusLayouts_NexusSTEP 19 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
