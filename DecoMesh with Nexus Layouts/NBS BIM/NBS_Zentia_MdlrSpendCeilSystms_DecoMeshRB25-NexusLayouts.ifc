Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2025-10-17T11:51:40
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusARRAY, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusARRAY:222171
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Powder-coated; Material: Steel,Aluminium; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Contemporary and modern mesh installed on Gridline suspended ceiling systems with a 50% open area, in a range of Nexus design layouts.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: DecoMesh RB25 - Nexus layouts; Name: ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusARRAY_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusARRAY; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/642ff0bf-64cb-48d4-b5bb-05bb5d713805/294b12a5-1473-4c9b-bf66-88ddef95c3c3; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 2 mm-thick mesh infills.Mixture of white (RAL 9003), aluminium (RAL 9006) and black (RAL 9005) in prescribed pattern; SystemAccessories: Hold down clips (BPCHDC),Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: Europe; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill mesh: 3.95 kg/m²; ReactionToFire: To EN 13501-1, mesh: Euroclass A2-s1, d0; VOC: A+; Design: ARRAY; MeshSize: Long diagonal, 16 mm; short diagonal, 8 mm; open area: 50%
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusARRAY 2 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusBERG, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusBERG:222179
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Powder-coated; Material: Steel,Aluminium; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Contemporary and modern mesh installed on Gridline suspended ceiling systems with a 50% open area, in a range of Nexus design layouts.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: DecoMesh RB25 - Nexus layouts; Name: ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusBERG_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusBERG; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/642ff0bf-64cb-48d4-b5bb-05bb5d713805/294b12a5-1473-4c9b-bf66-88ddef95c3c3; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 2 mm-thick mesh infills.Mixture of white (RAL 9003), aluminium (RAL 9006) and black (RAL 9005) in prescribed pattern; SystemAccessories: Hold down clips (BPCHDC),Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: Europe; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill mesh: 3.95 kg/m²; ReactionToFire: To EN 13501-1, mesh: Euroclass A2-s1, d0; VOC: A+; Design: BERG; MeshSize: Long diagonal, 16 mm; short diagonal, 8 mm; open area: 50%
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusBERG 2 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusEXCLAIM, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusEXCLAIM:222187
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Powder-coated; Material: Steel,Aluminium; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Contemporary and modern mesh installed on Gridline suspended ceiling systems with a 50% open area, in a range of Nexus design layouts.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: DecoMesh RB25 - Nexus layouts; Name: ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusEXCLAIM_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusEXCLAIM; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/642ff0bf-64cb-48d4-b5bb-05bb5d713805/294b12a5-1473-4c9b-bf66-88ddef95c3c3; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 2 mm-thick mesh infills.Mixture of white (RAL 9003), aluminium (RAL 9006) and black (RAL 9005) in prescribed pattern; SystemAccessories: Hold down clips (BPCHDC),Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: Europe; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill mesh: 3.95 kg/m²; ReactionToFire: To EN 13501-1, mesh: Euroclass A2-s1, d0; VOC: A+; Design: EXCLAIM; MeshSize: Long diagonal, 16 mm; short diagonal, 8 mm; open area: 50%
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusEXCLAIM 2 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusPIXAL, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusPIXAL:222195
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Powder-coated; Material: Steel,Aluminium; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Contemporary and modern mesh installed on Gridline suspended ceiling systems with a 50% open area, in a range of Nexus design layouts.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: DecoMesh RB25 - Nexus layouts; Name: ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusPIXAL_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusPIXAL; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/642ff0bf-64cb-48d4-b5bb-05bb5d713805/294b12a5-1473-4c9b-bf66-88ddef95c3c3; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 2 mm-thick mesh infills.Mixture of white (RAL 9003), aluminium (RAL 9006) and black (RAL 9005) in prescribed pattern; SystemAccessories: Hold down clips (BPCHDC),Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: Europe; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill mesh: 3.95 kg/m²; ReactionToFire: To EN 13501-1, mesh: Euroclass A2-s1, d0; VOC: A+; Design: PIXAL; MeshSize: Long diagonal, 16 mm; short diagonal, 8 mm; open area: 50%
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusPIXAL 2 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusSTEP, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusSTEP:222203
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Powder-coated; Material: Steel,Aluminium; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Contemporary and modern mesh installed on Gridline suspended ceiling systems with a 50% open area, in a range of Nexus design layouts.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: DecoMesh RB25 - Nexus layouts; Name: ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusSTEP_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusSTEP; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/642ff0bf-64cb-48d4-b5bb-05bb5d713805/294b12a5-1473-4c9b-bf66-88ddef95c3c3; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 2 mm-thick mesh infills.Mixture of white (RAL 9003), aluminium (RAL 9006) and black (RAL 9005) in prescribed pattern; SystemAccessories: Hold down clips (BPCHDC),Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: Europe; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill mesh: 3.95 kg/m²; ReactionToFire: To EN 13501-1, mesh: Euroclass A2-s1, d0; VOC: A+; Design: STEP; MeshSize: Long diagonal, 16 mm; short diagonal, 8 mm; open area: 50%
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_DecoMeshRB25-NexusLayouts_NexusSTEP 2 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
