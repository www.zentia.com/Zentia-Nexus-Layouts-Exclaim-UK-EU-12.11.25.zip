Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2025-10-17T11:52:52
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusARRAY, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusARRAY:222195
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Oplia - Nexus layouts; Name: ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusARRAY_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusARRAY; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/1c1349b3-853f-47d7-a397-da684f40138f/a7e71821-583e-4c1e-ab1b-934228e54439; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 17 mm-thick mineral tiles, Global White; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill units: 4.6 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: αw = 0.65 (H); Class C; SoundAttenuation: Infill units: Dnfw = 37 dB; WeightedSoundReductionIndexRw: Infill units: 20 dB; VOCEmissions: Infill units: The VOC emission performance in accordance with the French labelling requirements: A+; FormaldehydeEmissions: Infill units: To EN 13964, formaldehyde emission level E1 = Best test result possible; ColourLightReflectanceValueLRV: Infill units: 86%; CleanroomClassification: To ISO 14644-1, ISO 5; RelativeHumidity: Infill units: 95%; Design: ARRAY
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusARRAY 17 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusBERG, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusBERG:222203
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Oplia - Nexus layouts; Name: ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusBERG_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusBERG; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/1c1349b3-853f-47d7-a397-da684f40138f/a7e71821-583e-4c1e-ab1b-934228e54439; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 17 mm-thick mineral tiles, Global White; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill units: 4.6 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: αw = 0.65 (H); Class C; SoundAttenuation: Infill units: Dnfw = 37 dB; WeightedSoundReductionIndexRw: Infill units: 20 dB; VOCEmissions: Infill units: The VOC emission performance in accordance with the French labelling requirements: A+; FormaldehydeEmissions: Infill units: To EN 13964, formaldehyde emission level E1 = Best test result possible; ColourLightReflectanceValueLRV: Infill units: 86%; CleanroomClassification: To ISO 14644-1, ISO 5; RelativeHumidity: Infill units: 95%; Design: BERG
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusBERG 17 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusEXCLAIM, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusEXCLAIM:222211
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Oplia - Nexus layouts; Name: ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusEXCLAIM_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusEXCLAIM; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/1c1349b3-853f-47d7-a397-da684f40138f/a7e71821-583e-4c1e-ab1b-934228e54439; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 17 mm-thick mineral tiles, Global White; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill units: 4.6 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: αw = 0.65 (H); Class C; SoundAttenuation: Infill units: Dnfw = 37 dB; WeightedSoundReductionIndexRw: Infill units: 20 dB; VOCEmissions: Infill units: The VOC emission performance in accordance with the French labelling requirements: A+; FormaldehydeEmissions: Infill units: To EN 13964, formaldehyde emission level E1 = Best test result possible; ColourLightReflectanceValueLRV: Infill units: 86%; CleanroomClassification: To ISO 14644-1, ISO 5; RelativeHumidity: Infill units: 95%; Design: EXCLAIM
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusEXCLAIM 17 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusPIXAL, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusPIXAL:222219
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Oplia - Nexus layouts; Name: ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusPIXAL_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusPIXAL; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/1c1349b3-853f-47d7-a397-da684f40138f/a7e71821-583e-4c1e-ab1b-934228e54439; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 17 mm-thick mineral tiles, Global White; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill units: 4.6 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: αw = 0.65 (H); Class C; SoundAttenuation: Infill units: Dnfw = 37 dB; WeightedSoundReductionIndexRw: Infill units: 20 dB; VOCEmissions: Infill units: The VOC emission performance in accordance with the French labelling requirements: A+; FormaldehydeEmissions: Infill units: To EN 13964, formaldehyde emission level E1 = Best test result possible; ColourLightReflectanceValueLRV: Infill units: 86%; CleanroomClassification: To ISO 14644-1, ISO 5; RelativeHumidity: Infill units: 95%; Design: PIXAL
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusPIXAL 17 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusSTEP, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusSTEP:222227
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Oplia - Nexus layouts; Name: ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusSTEP_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusSTEP; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/1c1349b3-853f-47d7-a397-da684f40138f/a7e71821-583e-4c1e-ab1b-934228e54439; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 17 mm-thick mineral tiles, Global White; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 44; Weight: Infill units: 4.6 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: αw = 0.65 (H); Class C; SoundAttenuation: Infill units: Dnfw = 37 dB; WeightedSoundReductionIndexRw: Infill units: 20 dB; VOCEmissions: Infill units: The VOC emission performance in accordance with the French labelling requirements: A+; FormaldehydeEmissions: Infill units: To EN 13964, formaldehyde emission level E1 = Best test result possible; ColourLightReflectanceValueLRV: Infill units: 86%; CleanroomClassification: To ISO 14644-1, ISO 5; RelativeHumidity: Infill units: 95%; Design: STEP
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_Oplia-NexusLayouts_NexusSTEP 17 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
