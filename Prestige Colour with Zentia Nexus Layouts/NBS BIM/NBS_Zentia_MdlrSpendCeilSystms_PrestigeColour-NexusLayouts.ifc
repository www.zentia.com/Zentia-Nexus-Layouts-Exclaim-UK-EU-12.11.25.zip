Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2025-10-17T11:53:28
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusARRAY, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusARRAY:222167
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth,Textured; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts. Prestige tiles have a smooth, finely textured surface providing good sound absorption and attenuation; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Prestige Colour - Nexus layouts; Name: ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusARRAY_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusARRAY; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/c6ebe881-0268-4938-825f-aef4560d2924/1feeaefe-d120-4180-bc4d-ff12791058a0; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 19 mm-thick mineral tiles.Mixture of Black (BK1), Light Grey (GY1) and Mid Grey (GY2) in prescribed pattern; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 76; Weight: Infill units: 5 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: 0.45 to 0.60(H); class C to D; Design: ARRAY
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusARRAY 19 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusBERG, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusBERG:222175
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth,Textured; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts. Prestige tiles have a smooth, finely textured surface providing good sound absorption and attenuation; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Prestige Colour - Nexus layouts; Name: ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusBERG_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusBERG; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/c6ebe881-0268-4938-825f-aef4560d2924/1feeaefe-d120-4180-bc4d-ff12791058a0; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 19 mm-thick mineral tiles.Mixture of Black (BK1), Light Grey (GY1) and Mid Grey (GY2) in prescribed pattern; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 76; Weight: Infill units: 5 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: 0.45 to 0.60(H); class C to D; Design: BERG
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusBERG 19 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusEXCLAIM, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusEXCLAIM:222183
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth,Textured; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts. Prestige tiles have a smooth, finely textured surface providing good sound absorption and attenuation; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Prestige Colour - Nexus layouts; Name: ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusEXCLAIM_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusEXCLAIM; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/c6ebe881-0268-4938-825f-aef4560d2924/1feeaefe-d120-4180-bc4d-ff12791058a0; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 19 mm-thick mineral tiles.Mixture of Black (BK1), Light Grey (GY1) and Mid Grey (GY2) in prescribed pattern; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 76; Weight: Infill units: 5 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: 0.45 to 0.60(H); class C to D; Design: EXCLAIM
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusEXCLAIM 19 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusPIXAL, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusPIXAL:222191
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth,Textured; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts. Prestige tiles have a smooth, finely textured surface providing good sound absorption and attenuation; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Prestige Colour - Nexus layouts; Name: ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusPIXAL_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusPIXAL; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/c6ebe881-0268-4938-825f-aef4560d2924/1feeaefe-d120-4180-bc4d-ff12791058a0; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 19 mm-thick mineral tiles.Mixture of Black (BK1), Light Grey (GY1) and Mid Grey (GY2) in prescribed pattern; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 76; Weight: Infill units: 5 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: 0.45 to 0.60(H); class C to D; Design: PIXAL
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusPIXAL 19 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusSTEP, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusSTEP:222199
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Smooth,Textured; Material: Mineral fibre,Steel; Shape: Square,Rectangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Suspended ceiling system with lay-in mineral ceiling tiles in a selection of Nexus design layouts. Prestige tiles have a smooth, finely textured surface providing good sound absorption and attenuation; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Prestige Colour - Nexus layouts; Name: ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusSTEP_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusSTEP; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/c6ebe881-0268-4938-825f-aef4560d2924/1feeaefe-d120-4180-bc4d-ff12791058a0; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 1
Type - NBS_Data - CeilingSupport: Gridline 24 butt cut and joggled, Global White,Gridline 24 butt cut and joggled, Black; CeilingUnits: 1200 x 600 and 600 x 600 mm board edge 19 mm-thick mineral tiles.Mixture of Black (BK1), Light Grey (GY1) and Mid Grey (GY2) in prescribed pattern; SystemAccessories: Single tee adaptor clip (BPSTAC),Other,None; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; A1-A3ProductionStage: 5.26; Recyclability: 100%; RecycledContent: 76; Weight: Infill units: 5 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0; support grid: Euroclass A1; SoundAbsorption: Infill units: 0.45 to 0.60(H); class C to D; Design: STEP
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_PrestigeColour-NexusLayouts_NexusSTEP 19 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
